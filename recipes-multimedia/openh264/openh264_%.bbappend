EXTRA_OEMAKE:append = " ARCH=arm"